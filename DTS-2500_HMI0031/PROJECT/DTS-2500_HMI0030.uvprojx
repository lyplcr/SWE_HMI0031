# Keil uVision project DTS-2500_HMI0030.uvprojx, settings and files
target DTS-2500_HMI0030 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DTS-2500_HMI0030 +hex
  AfterMake: fromelf --bin -o ..\BIN\SWE_HMI0031(SYOR1.0.0.0)_160122.bin ..\OUTPUT\OBJ\DTS-2500_HMI0030.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_HS,USE_EMBEDDED_PHY
  c include: ..\APP\inc;..\BSP\inc;..\FATFS;..\FWLIB\inc;..\UTILS\inc;..\USER;..\LWIP-1.3.1\port;..\LWIP-1.3.1\src\include;..\LWIP-1.3.1\src\include\lwip;..\LWIP-1.3.1\src\include\ipv4;..\USB\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\USB\Libraries\STM32_USB_HOST_Library\Core\inc;..\USB\Libraries\STM32_USB_OTG_Driver\inc;..\USB\USB_APP
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\USER\DTS-2500_HMI0030.sct
  group USER
    ../USER/: main.c
    ../UTILS/inc/: global.h tools.h pcm.h gui.h report.h cmd.h prm.h prm_struct.h
    ../BSP/inc/: bsp.h bsp_lcd.h
  group APP
    ../APP/src/: PageManage.c initial.c MainPage.c TestParameter.c TestSelect.c SearchReport.c TestReport.c DetailReport.c SystemSet.c ControlParameter.c CalibrationTable.c TimeDate.c OnlineParameter.c SoftActive.c SystemPassword.c CalibrationParameter.c ForceCalibration.c TestAfterDispose.c AdvanceParameter.c ModelSelect.c UnitSelect.c SystemBackup.c SystemRestore.c SystemInfomation.c HardTest.c LinkMode.c UserLogin.c ChannelSelect.c TestTypeSelect.c CurveShow.c
  group BSP
    ../BSP/src/: bsp.c bsp_assert.c bsp_timer.c bsp_uart.c bsp_io.c bsp_pcf8563.c bsp_crc16.c bsp_date.c bsp_print.c bsp_sdio_sd.c bsp_ra8875.c bsp_lcd.c bsp_flash.c bsp_spi_flash.c bsp_uid.c bsp_lan8720.c client.c netconf.c bsp_rtc.c
    ../USB/USB_APP/: usb_bsp.c usbh_it.c usbh_usr.c
  group UTILS
    ../UTILS/src/: global.c typewrite.c gui.c tools.c cmd.c active.c pcm.c prm.c protocol.c report.c usb.c ustring.c ustdlib.c isqrt.c printer.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_fsmc.c stm32f4xx_flash.c stm32f4x7_eth.c stm32f4xx_syscfg.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group CMSIS
    ../USER/: startup_stm32f40_41xxx.s system_stm32f4xx.c stm32f4xx_it.c
  group FATFS
    ../FATFS/: diskio.c ff.c
    ../FATFS/option/: ccsbcs.c
  group LWIP
    ../LWIP-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c
    ../LWIP-1.3.1/src/core/: stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c dhcp.c init.c mem.c memp.c netif.c pbuf.c raw.c
    ../LWIP-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP-1.3.1/src/netif/: etharp.c
    ../LWIP-1.3.1/port/: ethernetif.c
  group USB
    ../USB/Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../USB/Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/Libraries/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_core.c usb_hcd.c
  group Doc
    ../Doc/: BUG日志.txt 固件升级日志.txt 程序标准格式.txt
    ../USER/: MY_DEBUG.H
    ../UTILS/inc/: config.h
software components: CMSIS:CORE 4.3.0
